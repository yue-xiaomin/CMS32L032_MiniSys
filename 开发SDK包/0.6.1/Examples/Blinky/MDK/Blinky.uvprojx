# Keil uVision project Blinky.uvprojx, settings and files
target CMS32L032 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: CMS32L032GE24SS Cmsemicon
  pack: Cmsemicon.CMS32L032.0.6.0
  cpu: IRAM(0x20000000,0x01000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Blinky +hex
  c flags: Optim=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group Source
    ../: main.c
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0
