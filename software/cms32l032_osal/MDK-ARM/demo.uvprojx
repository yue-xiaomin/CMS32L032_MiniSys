# Keil uVision project demo.uvprojx, settings and files
target demo (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: CMS32L032GE24NA Cmsemicon
  pack: Cmsemicon.CMS32L032.0.6.1
  cpu: IRAM(0x20000000,0x01000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: demo +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=Objects\@L.bin !L
  AfterMake: .\keil5_disp_size_bar.exe
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\CMSIS\Include;..\CMSIS\Device\Include;..\CMSIS\Device\Source;..\Driver\inc;..\User;..\Board;..\OSAL\osal;..\OSAL\hal;..\OSAL\app
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group User
    ../User/: main.c
    ../OSAL/app/: osal_main.c print_task.c statistics_task.c
  group OSAL
    ../OSAL/hal/: timer.c
    ../OSAL/osal/: osal.c osal_event.c osal_memory.c osal_msg.c osal_timer.c
  group Board
    ../Board/: delay.c led.c dataflash.c i2c.c
  group Startup
    ../CMSIS/Device/Source/ARM/: startup_CMS32L032.s
  group Device
    ../CMSIS/Device/Source/: system_CMS32L032.c
  group Driver
    ../Driver/src/: rst.c clk.c gpio.c pcbz.c elc.c retarget.c flash.c flash_user.c iica.c iica_user.c intp.c intp_user.c key.c key_user.c adc.c adc_user.c rtc.c rtc_user.c sci.c sci_user.c spi.c spi_user.c tim4.c tim4_user.c wdt.c wdt_user.c
